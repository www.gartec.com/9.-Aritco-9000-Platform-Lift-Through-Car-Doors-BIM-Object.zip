Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-01-18T15:24:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Wed Jan 18 15:24:35 2017* Host: NCL-PI08* Database: C:\Users\KovacsG\AppData\Local\Temp\{5BA0B7FC-3FF1-4D02-B8F7-8A458FA949BF}\ifc* Database version: 5507* Database creation date: Wed Jan 18 15:24:33 2017* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Wed Jan 18 15:24:34 2017* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Wed Jan 18 15:24:34 2017* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: X:\NBL\Manufacturer\G\Gartec Ltd_17666\NBLA0684\Authoring\IFC\NBS_GartecLtd_VrtclLftngPltfrms_Artico9000CabinLift_ThroughCarDoors.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcTransportElement: LeftRightAccess_1000x1400mm, NBS_GartecLtd_VrtclLftngPltfrms_Artico9000CabinLift_ThroughCarDoors:LeftRightAccess_1000x1400mm:53061
In: Level 1
Type - PredefinedType: ELEVATOR; Classification: Pr_65_80_47_95 (Uniclass2015); Material: NBS_Concept, NBS_Glass_Single
Type - NBS_General - Author: NBS; BIMObjectName: NBS_GartecLtd_VerticalLiftingPlatforms_Artico9000CabinLift_ThroughCarDoors-1000x1400mm; ManufacturerName: Gartec Ltd; ManufacturerURL: www.gartec.com; NBSCertification: www.nationalbimlibrary.com/cert/rgnuezbu; NBSDescription: Vertical lifting platforms; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 90-80-65/350; NBSTypeID: n/a; ProductInformation: www.gartec.com/aritco-9000/; Revision: n/a; Uniclass2015Code: Pr_65_80_47_95; Uniclass2015Title: Vertical lifting platforms; Uniclass2015Version: Products v1.3; Version: 1
Type - NBS_Data - Accessories: Cabin ceiling light; Capacity: 400 kg; CarrierControlFeaturesFinish: Natural anodised aluminim with coloured text; CarrierControlFeaturesFormat: Illuminated automatic one touch push buttons, emergency stop button, overload indicator and alarm button with siren, optional braille buttons; CarrierControlFeaturesMaterial: Aluminium face plate; CarrierFinish: As standard: Black embossed dots on COP wall, white grey for other sides (alternative colours, finishes and mirrors optional); CarrierFloorCovering: n/a; CarrierFloorCoveringOptions: Choice of 8 Vinyl or Rubber floorings; CarrierFormat: Full height; CarrierHandRailsFinish: n/a; CarrierHandRailsFormat: Staight; CarrierHandRailsLocation: On long side under COP (additional handrails available); CarrierHandRailsMaterial: As standard: Stainless steel; CarrierMaterial: Aluminium uprights with wooden panels; CarrierRailMaterialOptions: Oak, Stainless steel; CarrierRailOptions: Bump rails, hand rails; Certification: CE Marked in accordance with the Revised Machinery Directive (2006/42/EC) and prEN81-41; DoorsArrangement: Through; DoorsClearOpeningWidthMinimum: 900 mm; DoorsFireRating: n/a; DoorsFrameFinish: Powder coated; DoorsFrameMaterial: Integral to shaft enclosure; DoorsInfill: GL (Glazed door as standard); DoorsInfillFinish: Powder coated; DoorsOperation: Landing: Swing door with closer, Car door: Folding busmatic doors; DriveType: Stationary screw and rotating nut; DutyCycle: 20 (maximum); ElectricalSupply: 230 V, 1 phase, 20 A, 50 HZ; EnclosureFireRating: n/a; EnclosureFormat: Floor fixings and mast support in any direction.; EnclosureFrameFinish: Powder coated; EnclosureFrameMaterialComposition: Galvanized low carbon steel and aluminium , Low carbon steel; EnclosureInfill: White vinyl coated double skinned steel panels filled with mineral wool; EnclosureInfillFinish: n/a; EnclosureInfillOptions: White vinyl coated double skinned steel panels filled with mineral wool, toughened and laminated glass panels; Environment: Indoor; LandingControlsCallStations: One touch buttons; LandingControlsFeatures: Flush call buttons, Lockable isolator within 2 metres and in view of electrical cabinet located at the upper landing, Battery back up; MachineRoom: Integral to enclosure; Motor: 3 kW, 400 V, 3 phase, 50 Hz, 18-4.7 A; NumberOfStopsMaximum: 6; OverallDimensionsDepthMaximum: 1465 mm; OverallDimensionsWidthMaximum: 1630 mm; PlatformSizeOptions: 1000 x 1400 mm, 1100 x 1400 mm; Ramp: 75 mm pit, no ramp required; RatedSpeed: 0.15 m/s; SafeWorkingLoadMinimum: 400 kg; TravelHeightRange: 2100-13000 mm; UserGroup: Ambulant and wheelchair users
Type - Pset_TransportElementCommon - FireExit: no; Reference: n/a
Type - Pset_TransportElementElevator - ClearDepth: 1000 mm; ClearHeight: 2100 mm; ClearWidth: 1400 mm
Type - Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 3000; HasProtectiveEarth: yes; InsulationStandardClass: n/a; IP_Code: n/a; NominalCurrent: 18; NominalFrequencyRange: 50 Hz; NominalVoltage: 400; NumberOfPoles: 0; PhaseAngle: 0; PhaseReference: n/a; UsageCurrent: 4.7
Type - COBie - AccessibilityPerformance: Exceeds building regulations Part M; AssetType: Fixed; Category: Generic Models; CodePerformance: To BS 6440 and ISO 9386-1; Color: RAL 9003; Constituents: n/a; Description: Interior, fully enclosed platform lift with through car entry and exit doors; DurationUnit: year; ExpectedLife: 20 years +; Features: Fully enclosed lift car, wide range of option variations, vertical travel to 13 m, 3 day installation; Finish: Various available; Grade: n/a; Manufacturer: sales@gartec.com; Material: n/a; ModelNumber: n/a; ModelReference: Artico 9000 Cabin Lift Through Car Entry and Exit Doors; Name: VerticalLiftingPlatforms_Artico9000CabinLift_ThroughCarDoors-1000x1400mm_GartecLtd; NominalHeight: 2100 mm; NominalLength: 1000 mm; NominalWidth: 1400 mm; ReplacementCost: n/a; Shape: Rectangular; Size: 1400 x 1000 x 2100 mm cabin; SustainabilityPerformance: Exempt from BREEAM; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
